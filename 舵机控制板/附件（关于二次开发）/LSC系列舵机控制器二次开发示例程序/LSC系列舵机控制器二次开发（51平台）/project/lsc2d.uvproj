# Keil uVision project lsc2d.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lsc2d +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ../src/: STARTUP.A51
  group Main
    ../src/: lsc2d.c lsc2d.h main.c typedef.h uart.c uart.h
